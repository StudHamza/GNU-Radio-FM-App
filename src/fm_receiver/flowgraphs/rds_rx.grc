options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rds_rx
    output_language: python
    title: Stereo FM receiver and RDS Decoder
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '6'
  states: {}
- name: done
  id: variable
  parameters:
    comment: |-
      0 == Scanning in progress
      1 == Finished scanning
    value: '0'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: 2**7
  states: {}
- name: fir_cutoff
  id: variable_qtgui_range
  parameters:
    label: Cutoff Frequency
    start: 20e3
    step: 1e3
    stop: 200e3
    value: 135e3
  states: {}
- name: fir_transition_width
  id: variable_qtgui_range
  parameters:
    label: Transition width
    start: 10e3
    step: 1e3
    stop: 40e3
    value: 20e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0,1, 1
    label: Frequency
    start: '77'
    step: '0.1'
    stop: '108'
    value: '88.7'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: freq*1e6-freq_offset
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0,1, 1
    label: RF Gain
    start: '0'
    step: '1'
    stop: '49.6'
    value: '40'
  states: {}
- name: mode
  id: variable
  parameters:
    value: '1'
  states: {}
- name: mute
  id: variable
  parameters:
    value: '1'
  states: {}
- name: num_items
  id: variable
  parameters:
    value: samp_rate*2
  states: {}
- name: pilot_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: '240000'
    type: complex_band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: '151'
    samp_rate: '19000'
    sym_rate: 19000/8
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: tau
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: tau_1
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0,1, 1
    label: Volume
    start: '-20'
    step: '1'
    stop: '10'
    value: '-5'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '53'
    max_gain: '1000'
    rate: '2e-3'
    reference: '0.585'
    type: complex
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    comment: |-
      FM deemphasis,
      Time constant in seconds 
      (75us in US, 50us in EUR)
    samp_rate: '48000'
    tau: tau
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: tau
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * math.pi * 19020 / 240000
    min_freq: 2 * math.pi * 18980 / 240000
    w: '0.001'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation) / (2*math.pi*75000)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: (len(pilot_taps) - 1) // 2
    type: float
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: done
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0 if mute else 10 ** (1. * volume / 10)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0 if mute else 10 ** (1. * volume / 10)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: mode
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: Output.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: '48000'
  states: {}
- name: device_arguments
  id: parameter
  parameters:
    label: device_arguments
    type: str
    value: '0'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2*math.pi / 100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport math\nfrom gnuradio import gr\nimport pmt\nfrom time import sleep\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, fft_size=2**7, samp_rate=2.048e6, freq=88e6,done=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        self.done = done\n        self.samp_rate = samp_rate  \n        self.fft_size = fft_size\n        self.freq = freq\n        self.threshold =0.3\n        self.num_items = samp_rate*2\n\n        bin_bandwidth = samp_rate / fft_size\n        fm_bandwidth = 200e3\n\n        station_size = math.ceil(fm_bandwidth / bin_bandwidth)\n        self.half_station_size = station_size / 2 if station_size % 2 == 0 else (station_size + 1) / 2\n        self.compute_candidate_freqs()\n\n        self.data = np.array([], dtype=np.float32)\n\n        self.power_per_station = np.zeros(self.candidate_freqs.size)\n\n        self.detected_stations= set()\n\n        self.message_port_register_out(pmt.intern(\"done\"))\n\n\n\n    def work(self, input_items, output_items):\n\n        if self.done == 1: \n            return len(input_items[0])\n        \n        self.data = np.concatenate((self.data, input_items[0]))\n\n        if len(self.data) < self.num_items:\n            return len(input_items[0])\n        \n        data = self.data\n\n        self.compute_candidate_freqs() \n\n        for i in range(0, len(data), self.fft_size):\n            if i + self.fft_size > len(data):\n                break\n                \n            data_chunk = data[i:i+self.fft_size]\n            \n            for j, station_bin in enumerate(self.candidate_freqs_bin):\n                start_bin = int(station_bin - self.half_station_size)\n                end_bin = int(station_bin + self.half_station_size)\n                \n                # Ensure we don't go out of bounds\n                start_bin = max(0, start_bin)\n                end_bin = min(len(data_chunk), end_bin)\n                \n                if start_bin < end_bin:\n                    potential_station = np.sum(np.abs(data_chunk[start_bin:end_bin])**2)\n                    self.power_per_station[j] += potential_station\n\n\n        normalized_power_per_station = self.normalize(self.power_per_station)\n\n        # Find active stations\n        active_indices = np.where(normalized_power_per_station > self.threshold)[0]\n\n        # Group adjacent active indices\n        groups = []\n        if len(active_indices) > 0:\n            group = [active_indices[0]]\n            for idx in active_indices[1:]:\n                if idx == group[-1] + 1:\n                    group.append(idx)\n                else:\n                    groups.append(group)\n                    group = [idx]\n            groups.append(group)  # append the last group\n\n        # Pick max power freq in each group\n        for group in groups:\n            max_idx = group[np.argmax(normalized_power_per_station[group])]\n  \n            self.detected_stations.add(float(self.candidate_freqs[max_idx]))\n\n        self.done = 1\n        msg = pmt.cons(pmt.intern(\"value\"), pmt.from_double(1))\n        self.message_port_pub(pmt.intern(\"done\"), msg)\n\n        self.clean_up()\n        \t\n        return len(input_items[0])\n\n    def clean_up(self):\n        self.power_per_station = np.zeros(self.candidate_freqs.size)\n        self.data = np.array([], dtype=np.float32)  # clear data for next batch\n\n    def compute_candidate_freqs(self):\n        step_size = 100e3\n        start_freq = self.round_to_3_sigfigs(self.freq -  self.fft_size * (self.samp_rate / self.fft_size) / 2)\n        end_freq = self.round_to_3_sigfigs(self.freq +  self.fft_size * (self.samp_rate / self.fft_size) / 2)\n\n        self.candidate_freqs = np.arange(start_freq, end_freq, step_size)\n        self.candidate_freqs = self.candidate_freqs[1:-1]\n        self.candidate_freqs_bin = np.round(((self.candidate_freqs - self.freq) * self.fft_size / self.samp_rate) + self.fft_size / 2, 1).astype(int)\n\n    def get_staions(self):\n        return self.detected_stations\n    \n    def normalize(self, x):\n        \"\"\"Normalize array to 0-1 range\"\"\"\n        x_min, x_max = x.min(), x.max()\n        if x_max == x_min:\n            return np.zeros_like(x)\n        return (x - x_min) / (x_max - x_min)\n\n    def round_to_3_sigfigs(self, x):\n        \"\"\"Round to 3 significant figures\"\"\"\n        if x == 0:\n            return 0\n        else:\n            return round(x, -int(math.floor(math.log10(abs(x))) - 2))\n\n"
    done: done
    fft_size: fft_size
    freq: freq*10**6
    samp_rate: samp_rate
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pilot_taps
    type: fcc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(1.0,240000,15e3,2e3)
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(-2.1,240000,15e3,2e3)
    type: fff
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps_manchester
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, fir_cutoff, fir_transition_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '10'
    samp_rate: samp_rate / decimation
    taps: firdes.low_pass(1.0, samp_rate / decimation, 7.5e3, 5e3)
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: L+R
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: L-R
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: RDS
  states: {}
- name: note_0_2_0
  id: note
  parameters:
    note: Scanner Variables
  states: {}
- name: note_0_2_0_0
  id: note
  parameters:
    note: FM Scanner
  states: {}
- name: note_1
  id: note
  parameters:
    note: Pilot
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 6,0,1,1
    size: '1024'
    type: complex
    update_time: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    gui_hint: 4,0,1,1
    name: '"Base Band"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / decimation
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    freqhalf: 'False'
    name: '"FM Demod"'
    type: float
    update_time: '0'
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / (decimation*5)
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    freqhalf: 'False'
    name: '"L+R"'
    type: float
    update_time: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: 2**11
    srate: samp_rate
    type: float
    update_time: '0.05'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 5,0,1,1
    int_max: '0'
    int_min: '-80'
    legend: 'False'
    type: float
    update_time: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // decimation
    interp: '240000'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // decimation // 10
    interp: '19000'
    type: ccc
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters:
    freq: freq
    gui_hint: 3,0,1,1
  states: {}
- name: rds_panel_0_0
  id: rds_panel
  parameters:
    freq: freq
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '0'
    reset: freq
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: device_arguments
    bb_gain0: '20'
    freq0: freq_tune
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: freq_tune
    dc_removal0: 'False'
    dev_args: device_arguments
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq_tune
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '0']
- [blocks_delay_0, '0', fir_filter_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_wavfile_sink_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_1, '0', fir_filter_xxx_1_0, '0']
- [blocks_selector_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_selector_0, '1', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_0, '0']
- [blocks_vector_to_stream_0, '0', epy_block_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [epy_block_0, done, blocks_msgpair_to_var_0_0, inpair]
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1, '0', blocks_sub_xx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_1_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_1_0, '0', blocks_sub_xx_0, '1']
- [fir_filter_xxx_2, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', fir_filter_xxx_2, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]
- [rds_parser_0, out, rds_panel_0_0, in]
- [soapy_custom_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
