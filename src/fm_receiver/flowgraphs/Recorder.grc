options:
  parameters:
    author: hamza
    generate_options: hb
    id: MultipleRecorder
    output_language: python
    title: Multiple Recorder Block
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_offset_250
  id: variable
  parameters:
    value: freq_offset+250e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation) / (2*math.pi*75000)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: fname
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: fname
  id: parameter
  parameters:
    label: File Name
    type: str
    value: '0'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: 'Center Frequency '
    type: intx
    value: '0'
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: frequency offset
    type: intx
    value: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_250
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 130e3, 70e3)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 56e3
    win: window.WIN_HAMMING
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
