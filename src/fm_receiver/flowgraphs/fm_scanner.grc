options:
  parameters:
    author: hamza
    generate_options: qt_gui
    id: fm_scanner
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 87.7*10**6
    step: 200*10**3
    stop: 107.9*10**6
    value: 87.7*10**6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 48*10**3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr



      class blk(gr.sync_block):
          def __init__(self, threshold_value=0.5, vector_length=1024):
              """
              Args:
                  threshold_value: Threshold below which values are zeroed.
                  vector_length: Length of the float vector.
              """
              gr.sync_block.__init__(
                  self,
                  name='Vector Threshold',
                  in_sig=[(np.float32, vector_length)],
                  out_sig=[(np.float32, vector_length)],
              )
              self.threshold = threshold_value
              self.vector_length = vector_length

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]

              # Apply thresholding: zero values below threshold
              out[:] = np.where(in0 >= self.threshold, in0, 0.0)

              return len(output_items[0])
    threshold_value: '-12'
    vector_length: fft_size
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    name: '"Custom"'
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
    ymax: '0'
    ymin: '-20'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.1'
    type: float
    vlen: fft_size
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: freq
    samp_rate: 2.048*10**6
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_nlog10_ff_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
