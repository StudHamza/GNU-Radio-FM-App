options:
  parameters:
    author: hamza
    generate_options: no_gui
    id: fm_scanner
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: 2**7
  states: {}
- name: freq
  id: variable
  parameters:
    value: 87e6
  states: {}
- name: num_items
  id: variable
  parameters:
    value: int(samp_rate*2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048*10**6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_items
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    reserve_items: num_items
    type: float
    vlen: fft_size
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: 'True'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
